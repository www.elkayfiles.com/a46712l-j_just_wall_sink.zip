Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-01-08T15:51:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 08 15:51:44 2024 * Host: ZILBY3SGS3 * Database: C:\Users\SMalaya\AppData\Local\Temp\b97b0277-fdd2-48d8-bd76-28342d3144d5\7676fe7c-7bd3-4060-b67f-d6865948a35f\ifc * Database version: 5507 * Database creation date: Mon Jan 08 15:51:43 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 08 15:51:44 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 08 15:51:44 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: A46712L-J:A46712L-J, A46712L-J:A46712L-J:763226
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: A46712L-J
Pset_DistributionFlowElementCommon - Reference: A46712L-J; sets with these values: 2
